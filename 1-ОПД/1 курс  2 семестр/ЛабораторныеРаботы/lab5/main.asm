ORG 0x59A
WORD 0x4865
WORD 0x6C6C
WORD 0x6F20
WORD 0x576F
WORD 0x726C
WORD 0x6421
ORG 0x133
BEGIN: WORD 0x59A
CUR: WORD ?
FIRST: WORD ?
SECOND: WORD ?
MASK: WORD 0x00FF
START: CLA
LD BEGIN
ST CUR
S0: LD (CUR)+
ST SECOND
SWAB
ST FIRST
L1: IN 7
AND #0x40
BEQ L1
LD FIRST
AND MASK
BEQ STOP
OUT 6
L2: IN 7
AND #0x40
BEQ L2
LD SECOND
AND MASK
BEQ STOP
OUT 6
JUMP S0
STOP: HLT