ORG 0x000
V0: WORD $DEFAULT,0x180
V1: WORD $INT1,0x180 
V2: WORD $DEFAULT,0x180
V3: WORD $INT3,0x180
V4: WORD $DEFAULT,0x180 
V5: WORD $DEFAULT,0x180 
V6: WORD $DEFAULT,0x180 
V7: WORD $DEFAULT,0x180


ORG 0x050   
X:  WORD 0x0
MIN: WORD 0xFFE8
MAX: WORD 0x001A
MASK: WORD 0x00FF
DEFAULT: IRET


START: DI
CLA
OUT 0x1
OUT 0x5
OUT 0xB
OUT 0xD
OUT 0x11
OUT 0x15
OUT 0x19
OUT 0x1D
LD #0x9
OUT 3
LD #0xB
OUT 7
EI


MAIN: DI
LD X
ADD #3
CALL CHECK
ST X
EI
JUMP MAIN


INT3: 
; DI
CLA
IN 6
NOP
NEG
OUT 6
CALL CHECK
ST X
NOP
;EI
IRET


INT1: 
; DI
LD X
NOP
ASL
ASL
ADD X
SUB #3
OUT 2
NOP
; EI
IRET


CHECK: AND MASK
CMP MIN
BPL S1   
JUMP S2
S1: CMP MAX
BMI STOPCHECK
S2: 
NOP
LD MIN
STOPCHECK: 
NOP
RET 